SRC_URI_append_salvator-x += " \
    file://0001-drm-rcar-du-DU-CMM-support.patch \
"
